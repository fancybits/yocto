SRC_URI += "file://rk3566_defconfig;subdir=git/configs/"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
